## drivers/clk/zynq/Kconfig
```kconfig
config CLK_ZYNQ_WIZARD
	tristate "Xilinx clocking wizard driver"
	depends on ARCH_ZYNQ
	help
	  Enable the driver for Xilinx clocking wizard IP.
```
